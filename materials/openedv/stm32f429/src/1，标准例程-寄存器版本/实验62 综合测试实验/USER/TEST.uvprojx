# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=3 OneElfS=1 uC99=1
  c define: STM32F429xx,USE_USB_OTG_FS,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\DCMI;..\HARDWARE\USART2;..\HARDWARE\OV5640;..\HARDWARE\SDIO;..\HARDWARE\NAND;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\HARDWARE\SPBLCD;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\AUDIOCODEC\wav;..\PICTURE;..\APP;..\GUI;..\UCOSII\uC-LIB;..\UCOSII\uC-CPU;..\UCOSII\UCOS_BSP;..\UCOSII\uCOS-CONFIG;..\UCOSII\uCOS-II\Source;..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\MJPEG;..\MJPEG\JPEG;..\APP;..\HARDWARE\GSM;..\HARDWARE\USART3;..\HARDWARE\ETHERNET;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\AUDIOCODEC\ape;..\AUDIOCODEC\ape\apedec;..\AUDIOCODEC\flac;..\AUDIOCODEC\flac\flacdec;..\AUDIOCODEC\mp3;..\AUDIOCODEC\mp3\helix;..\AUDIOCODEC\wav;..\T9INPUT;..\ATKNCR;..\SMS;..\NES;..\LWIP;..\LWIP\arch;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\lwip;..\LWIP\lwip-1.4.1\src\include\netif;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server_demo;..\QR_ENCODE;..\ATKFREC;..\ATKQR
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f429xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/SPBLCD/: spblcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NAND/: nand.c ftl.c nandtester.c
    ../HARDWARE/24CXX/: myiic.c 24cxx.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/SAI/: sai.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt928.c gt9147.c gt9271.c ott2001a.c touch.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/MPU9250/: mpu9250.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/GSM/: gsm.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/OV5640/: ov5640.c sccb.c
    ../HARDWARE/ETHERNET/: lan8720.c stm32f4x7_eth.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/REMOTE/: remote.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: common.c spb.c ebook.c settings.c calendar.c picviewer.c calculator.c lyric.c audioplay.c videoplay.c notepad.c nesplay.c exeplay.c paint.c usbplay.c camera.c recorder.c netplay.c wirelessplay.c webcamera.c gyroscope.c appplay.c appplay_remote.c qrplay.c facereco.c gradienter.c beepplay.c keyplay.c ledplay.c phoneplay.c smsplay.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c memlcd.c
  group UCOSII_BSP
    ../UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
  group UCOSII_CPU
    ../UCOSII/uC-CPU/: cpu_core.c
    ../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSII_LIB
    ../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSII_CORE
    ../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII_CONFIG
    ../UCOSII/uCOS-CONFIG/: app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_dcd.c usb_hcd_int.c usb_dcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../USB/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_core.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_gamepad.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_storage_msd.c usbd_desc.c usbd_usr.c usbh_usr.c usb_app.c
  group AUDIOCODEC_WAV
    ../AUDIOCODEC/wav/: wavplay.c
  group AUDIOCODEC_MP3
    ../AUDIOCODEC/mp3/: mp3play.c
    ../AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../AUDIOCODEC/mp3/helix/arm/: asmpoly_thumb2_rvds.s asmmisc_rvds.s
  group AUDIOCODEC_FLAC
    ../AUDIOCODEC/flac/: flacplay.c
    ../AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
  group AUDIOCODEC_APE
    ../AUDIOCODEC/ape/: apeplay.c
    ../AUDIOCODEC/ape/apedec/: apedecoder.c entropy.c filter_16_11.c filter_32_10.c filter_64_11.c parser.c predictor.c predictor-arm.S
  group MJPEG
    ../MJPEG/: avi.c mjpeg.c
    ../MJPEG/JPEG/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctflt.c jidctfst.c jidctint.c jdsample.c jdcolor.c jquant2.c jquant1.c jdmerge.c jmemnobs.c wrppm.c
  group T9INPUT
    ../T9INPUT/: pyinput.c t9input.c
  group ATKNCR
    ../ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group ATKFREC
    ../ATKFREC/: atk_frec.c ATKFREC_SF.lib
  group ATKQR
    ../ATKQR/: atk_qrdecode.c ATK_QR_V1.4.lib
  group NES
    ../NES/: nes_main.c nes_apu.c nes_mapper.c nes_ppu.c nes_crc32.c 6502.s
  group SMS
    ../SMS/: sms_main.c sms_render.c sms_sn76496.c sms_vdp.c sms_z80a.c
  group LWIP_APP
    ../LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group LWIP_NETIF
    ../LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP_CORE
    ../LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_ARCH
    ../LWIP/arch/: sys_arch.c
  group LWIP_API
    ../LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group MPL
    ../HARDWARE/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../HARDWARE/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../HARDWARE/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../HARDWARE/MPU9250/MPL/mpl/: libmpllib.lib
  group QR_ENCODE
    ../QR_ENCODE/: qr_encode.c
  group README
    ../: readme.txt
