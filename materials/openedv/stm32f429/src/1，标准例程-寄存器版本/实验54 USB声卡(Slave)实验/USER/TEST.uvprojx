# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F429xx,USE_USB_OTG_FS,USE_STM324x9I_EVAL
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\USMART;..\HARDWARE\RTC;..\HARDWARE\RNG;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\AP3216C;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU9250;..\HARDWARE\MPU9250\MPL\driver\eMPL;..\HARDWARE\MPU9250\MPL\driver\include;..\HARDWARE\MPU9250\MPL\driver\stm32L;..\HARDWARE\MPU9250\MPL\eMPL-hal;..\HARDWARE\MPU9250\MPL\mllite;..\HARDWARE\MPU9250\MPL\mpl;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\DCMI;..\HARDWARE\USART2;..\HARDWARE\OV5640;..\HARDWARE\SDIO;..\HARDWARE\NAND;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\PICTURE;..\AUDIOCODEC\wav;..\APP;..\USB\STM32_USB_Device_Library\Class\audio\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f429xx.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/SAI/: sai.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/audio/src/: usbd_audio_core.c usbd_audio_out_if.c
  group USB_APP
    ../USB/USB_APP/: stm324x9i_usb_audio_codec.c usb_bsp.c usbd_desc.c usbd_usr.c
  group README
    ../: readme.txt
