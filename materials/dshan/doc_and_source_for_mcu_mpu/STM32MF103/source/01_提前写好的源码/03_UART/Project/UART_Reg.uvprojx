# Keil uVision project UART_Reg.uvprojx, settings and files
target UART_Reg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: UART_Reg +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CPU;..\Driver;..\Main
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Main
    ../Main/: main.c
  group Cpu
    ../CPU/: startup_stm32f10x_hd.s
  group Driver
    ../Driver/: driver_uart.c
