# Keil uVision project F103_Moduel.uvprojx, settings and files
target F103_Moduel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103_Moduel +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ModuleDrivers;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../smartdevice/cal;../smartdevice/kal;../smartdevice/input;../smartdevice/unittest;../smartdevice/device;../smartdevice/device/display;../smartdevice/config;../smartdevice/fonts;../smartdevice/text;../smartdevice/net;../smartdevice/device/uart;../smartdevice/smarthome
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ModuleDrivers
    ../ModuleDrivers/: driver_usart.c ring_buffer.c driver_key.c driver_fan.c driver_i2c.c driver_led.c driver_oled.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group kal
    ../smartdevice/kal/: kal_fan_device.c kal_gpio_key.c kal_led_device.c kal_oled_device.c kal_time.c kal_uart_dev.c
  group cal
    ../smartdevice/cal/: cal_fan_device.c cal_gpio_key.c cal_led_device.c cal_oled_device.c cal_time.c cal_uart_dev.c
  group input
    ../smartdevice/input/: gpio_key.c input_buffer.c input_system.c net_input.c
  group unittest
    ../smartdevice/unittest/: display_test.c fan_test.c input_test.c led_test.c net_test.c text_test.c
  group device
    ../smartdevice/device/: fan_device.c led_device.c
    ../smartdevice/device/uart/: uart_dev.c
  group display
    ../smartdevice/device/display/: display_device.c display_system.c oled_device.c
  group fonts
    ../smartdevice/fonts/: ascii_font.c font_manager.c font_system.c
  group text
    ../smartdevice/text/: show_text.c
    ../smartdevice/text/encoding/: encoding.c
  group net
    ../smartdevice/net/: esp8266.c net_device.c net_system.c
    ../smartdevice/net/at_command/: at_command.c
  group smathome
    ../smartdevice/smarthome/: message.c smarthome.c
  group crtp
    ../crtp/: uartlink.c crtp.c crtpservice.c ledservice.c
software components: CMSIS:CORE 4.3.0
